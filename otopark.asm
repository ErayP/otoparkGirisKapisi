			ORG 00H
			SJMP BASLA
			ORG 03H
			SJMP KESMEINT0
			ORG 0BH
			SJMP KESMET0
			ORG 13H
			SJMP KESMEINT1
			ORG 1BH
			SJMP KESMET1
			ORG 30H
BASLA:		CLR P1.0
			SETB P1.1
			CLR P1.2
			MOV IE,#8FH
			MOV TMOD,#21H
			MOV TH0,#-250
			MOV TL0,#-250
			MOV TH1,#HIGH(50000)
			MOV TL1,#LOW(50000)
			SETB IT0
			SETB IT1
			SETB PX1
			CLR TR0
			CLR TF0
			CLR TR1
			CLR TF1
			SJMP $
				
KESMEINT0:	SETB P1.0
			SETB P1.2
			SETB TR0
			SETB TR1
			CLR P1.1
			RETI
			
KESMEINT1:	MOV TH1,#HIGH(50000)
			MOV TL1,#LOW(50000)
			CLR P1.1
			SETB TR1
			
KESMET0:	CLR TF0
			CPL P1.2
			RETI

KESMET1:	CLR TF1
			CLR TR1
			JB P3.3 ,ENGELYOK
			SETB P1.0
			SETB TR0
			CLR P1.1
			SJMP ATLA
ENGELYOK:	CLR P1.0
			CLR TR0
			SETB P1.1
ATLA:		RETI
			
			
